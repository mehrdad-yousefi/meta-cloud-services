DESCRIPTION = "Python parsing module"
HOMEPAGE = "http://pyparsing.wikispaces.com/"
SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=fb46329938e6bc829b256e37d5c1e31a"

SRC_URI[md5sum] = "37adec94104b98591507218bc82e7c31"
SRC_URI[sha256sum] = "0007cd3f008eba4a203f1f6b4b133ddc352552c8808b694c88c23db56416e4e4"

inherit distutils pypi
