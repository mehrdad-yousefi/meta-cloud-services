PACKAGECONFIG[spice] = "--enable-spice,--disable-spice,spice,"

PACKAGECONFIG ?= "fdt spice virtfs attr cap-ng"
