PACKAGECONFIG ?= "fdt virtfs attr cap-ng"
PACKAGECONFIG_class-native = "fdt"
PACKAGECONFIG_class-nativesdk = "fdt"
