PACKAGECONFIG[spice] = "--enable-spice,--disable-spice,spice,"

PACKAGECONFIG ?= "spice virtfs"
PACKAGECONFIG_class-native = ""
PACKAGECONFIG_class-nativesdk = ""