inherit setuptools3
require python-sqlparse.inc
