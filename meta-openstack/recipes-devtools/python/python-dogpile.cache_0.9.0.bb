inherit setuptools
require python-dogpile.cache.inc


