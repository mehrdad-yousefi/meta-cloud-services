inherit setuptools3
require python3-eventlet.inc
