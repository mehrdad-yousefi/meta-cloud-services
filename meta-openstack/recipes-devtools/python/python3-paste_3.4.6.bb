DESCRIPTION = "Tools for using a Web Server Gateway Interface stack"
HOMEPAGE = "http://pythonpaste.org/"
SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://docs/license.txt;md5=1798f29d55080c60365e6283cb49779c"

PYPI_PACKAGE = "Paste"

SRC_URI[md5sum] = "4690566403fd89b01ae70a64245441b7"
SRC_URI[sha256sum] = "001370f4fcc7446006b52a39ed386341fce626605af711e0ec18ddb0b4912cb7"

inherit setuptools3 pypi
