inherit setuptools pypi
require python-contextlib2.inc

