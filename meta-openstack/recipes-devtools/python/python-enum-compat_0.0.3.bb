inherit setuptools
require python-enum-compat.inc
