require python-avahi.inc

inherit python-dir

RDEPENDS_${PN} += "python-core python-dbus"
