inherit setuptools
require python-kombu.inc

