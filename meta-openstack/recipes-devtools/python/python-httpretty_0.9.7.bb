inherit setuptools
require python-httpretty.inc

