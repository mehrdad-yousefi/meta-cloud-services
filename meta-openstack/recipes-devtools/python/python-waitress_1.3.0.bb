DESCRIPTION = "Waitress WSGI server"
HOMEPAGE = "https://pypi.python.org/pypi/waitress/"
SECTION = "devel/python"
LICENSE = "ZPL-2.1"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=78ccb3640dc841e1baecb3e27a6966b2"

SRC_URI[md5sum] = "884dbea5d7348f7db1b8ab76ef3a3a71"
SRC_URI[sha256sum] = "4e2a6e6fca56d6d3c279f68a2b2cc9b4798d834ea3c3a9db3e2b76b6d66f4526"

inherit setuptools pypi
