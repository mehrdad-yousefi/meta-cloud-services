inherit setuptools3 pypi
require python-kombu.inc
