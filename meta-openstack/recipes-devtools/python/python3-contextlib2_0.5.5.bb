inherit setuptools3 pypi
require python-contextlib2.inc

