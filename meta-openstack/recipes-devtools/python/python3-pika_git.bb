require python-pika.inc

inherit setuptools3
