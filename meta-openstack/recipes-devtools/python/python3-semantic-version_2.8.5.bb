DESCRIPTION = "A library which provides a few tools to handle SemVer in Python."
HOMEPAGE = "http://pypi.python.org/pypi/semantic_version"
SECTION = "devel/python"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://LICENSE;md5=4fb31e3c1c7eeb8b5e8c07657cdd54e2"

PYPI_PACKAGE = "semantic_version"

SRC_URI[md5sum] = "76d7364def7ee487b6153d40b13de904"
SRC_URI[sha256sum] = "d2cb2de0558762934679b9a104e82eca7af448c9f4974d1f3eeccff651df8a54"

inherit setuptools3 pypi

