inherit setuptools pypi
require python-kombu.inc

