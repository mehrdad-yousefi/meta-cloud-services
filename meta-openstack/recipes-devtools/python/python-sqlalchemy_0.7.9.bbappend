SRC_URI = "https://pypi.python.org/packages/source/S/SQLAlchemy/SQLAlchemy-0.7.9.tar.gz"

SRC_URI[md5sum] = "a0b58defc5ad0c7e1baeb932f62d08dd"
SRC_URI[sha256sum] = "4a89556cb55275d1af694dc4d5700d8bf0f83690bac16ab30340092ff25bb4d7"

