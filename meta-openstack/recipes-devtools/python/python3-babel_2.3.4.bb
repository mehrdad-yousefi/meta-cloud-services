require python-babel.inc
inherit setuptools3
