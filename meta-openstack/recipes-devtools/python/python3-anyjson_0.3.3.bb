require python-anyjson.inc
inherit setuptools3
