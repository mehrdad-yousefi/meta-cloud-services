inherit setuptools3
require python-waitress.inc
