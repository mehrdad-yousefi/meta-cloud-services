DESCRIPTION = "Waitress WSGI server"
HOMEPAGE = "https://pypi.python.org/pypi/waitress/"
SECTION = "devel/python"
LICENSE = "ZPL-2.1"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=78ccb3640dc841e1baecb3e27a6966b2"

SRC_URI[md5sum] = "8c5492d3c1a2e0cd80780175686dbb0f"
SRC_URI[sha256sum] = "e624c829656ffc99b33d661072b2814885ae92835cf835ee8ab283ddb7c915b9"

inherit setuptools pypi
