require python-cachetools.inc
inherit setuptools3
