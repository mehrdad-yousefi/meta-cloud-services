require python-beautifulsoup4.inc
inherit setuptools3
