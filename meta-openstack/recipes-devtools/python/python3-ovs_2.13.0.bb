DESCRIPTION = "Open vSwitch library"
HOMEPAGE = "https://pypi.python.org/pypi/ovs"
SECTION = "devel/python"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/Apache-2.0;md5=89aea4e17d99a7cacdbeed46a0096b10"

SRC_URI[md5sum] = "a4a252b3c1c7d3d2d4d622179cff178e"
SRC_URI[sha256sum] = "c158aaaddbad1f122222f45def50e2bb2f9af4e21a101f5be8488da66d4391f5"

inherit setuptools3 pypi
