inherit setuptools
require python-osc-lib.inc
