SERVICE_TOKEN = "password"
ADMIN_PASSWORD = "password"
SERVICE_PASSWORD = "password"
SERVICE_TENANT_NAME = "service"
DB_USER = "admin"
DB_PASSWORD = "admin"
