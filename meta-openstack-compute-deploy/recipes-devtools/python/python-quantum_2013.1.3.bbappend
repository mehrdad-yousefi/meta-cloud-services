inherit compute
